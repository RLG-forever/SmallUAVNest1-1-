# Keil uVision project EC17001-FCU71-24CAN.uvprojx, settings and files
target EC17001-FCU71-24CAN (5060960::V5.06 update 7 (build 960)::.\5.06)
  device: STM32F407VE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JK_YT_DOWN +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\PROJECT;..\FWLIB\inc;..\CMSIS\Include;..\SYSTEM\can;..\SYSTEM\diagnose;..\SYSTEM\io;..\SYSTEM\tmr;..\SYSTEM\modbus;..\SYSTEM\motor;..\SYSTEM\relay;..\SYSTEM\input;..\SYSTEM\adc;..\FWLIB\src;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6406
  group PROJECT
    ../PROJECT/: main.c stm32f4xx_it.c system_stm32f4xx.c
    ./: project.h project_cfg.h STM103REG.h
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
    ../SYSTEM/wdg/: wdg.c
    ../SYSTEM/adc/: adc.c adc.h
    ../SYSTEM/input/: input.c input.h
    ../SYSTEM/modbus/: modbus_master.c modbus_port.c modbus_port.h modbus_common.c modbus_common.h modbus_master.h modbus_slave.h modbus_slave.c
    ../SYSTEM/motor/: motor_control.c motor_control.h
    ../SYSTEM/relay/: relay.c relay.h
    ../SYSTEM/tmr/: tmr.c tmr.h
    ./: status_regs.h status_regs.c master_polling.h master_polling.c gateway_service.c gateway_service.h tick.h tick.c sequence.h sequence.c sequence_steps.h sequence_steps.c bsp_timer.h bsp_timer.c battery_swap.h battery_swap.c w25qxx.h w25qxx.c spi.h spi.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_tim.c stm32f4xx_spi.c
